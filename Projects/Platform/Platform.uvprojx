# Keil uVision project Platform.uvprojx, settings and files
target B-L475E-IOT01A (6140000::V6.14::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0-dev0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Platform
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x10000000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000800 size 0x7800
  scatter file: .\stm32l475.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: arduino.c arduino.h retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Drivers:Accelerometer 1.1.6, Board Support:Drivers:Basic I/O 1.1.6, Board Support:Drivers:Gyroscope 1.1.6, Board Support:Drivers:Humidity Sensor 1.1.6, Board Support:Drivers:Magnetometer 1.1.6, Board Support:Drivers:Pressure Sensor 1.1.6, Board Support:Drivers:Temperature Sensor 1.1.6, CMSIS Driver:SPI 1.2.0, CMSIS Driver:USART 1.2.0, CMSIS Driver:VIO:Board 1.0.0, CMSIS Driver:WiFi:ISM43362 1.8.0, Device:STM32Cube HAL:Common 1.11.1, Device:STM32Cube HAL:Cortex 1.11.1, Device:STM32Cube HAL:DMA 1.11.1, Device:STM32Cube HAL:GPIO 1.11.1, Device:STM32Cube HAL:I2C 1.11.1, Device:STM32Cube HAL:IRDA 1.11.1, Device:STM32Cube HAL:PWR 1.11.1, Device:STM32Cube HAL:RCC 1.11.1, Device:STM32Cube HAL:RNG 1.11.1, Device:STM32Cube HAL:SPI 1.11.1, Device:STM32Cube HAL:Smartcard 1.11.1, Device:STM32Cube HAL:UART 1.11.1, Device:STM32Cube HAL:USART 1.11.1, Device:Startup 1.3.1
